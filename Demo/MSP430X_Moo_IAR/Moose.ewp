# IAR project Moose.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa082
  ICC430.newCCIncludePaths: ..\Common\include; ..\..\Source\include; ..\..\Source\portable\IAR\MSP430X; $PROJ_DIR$
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: __DATA_MODEL_SMALL__
  A430.AUserIncludes: $PROJ_DIR$; ..\..\Source\portable\IAR\MSP430X
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: FreeRTOSConfig.h main.c
    ParTest/: ParTest.c
  group FreeRTOS
    ../Common/Minimal/: flash.c
    ../../Source/portable/MemMang/: heap_1.c
    ../../Source/: list.c tasks.c
    ../../Source/portable/IAR/MSP430X/: port.c portext.s43
